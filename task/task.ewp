# IAR project task.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G4 STM8L151G4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCIncludePath2: C:\STM8Projects\task\Libraries\STM8L15x_StdPeriph_Driver\src; C:\STM8Projects\task\Libraries\STM8L15x_StdPeriph_Driver\inc; C:\STM8Projects\task\Libraries\RFM69
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: task.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group library
    Libraries/STM8L15x_StdPeriph_Driver/src/: delay.c stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_it.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
    Libraries/RFM69/: RFM69.c RFM69registers.h
